# Keil uVision project HW3.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c interrupts.c init_hardware.c hockey_main.c hockey_main.h ece353_nrf24l01p.lib images.c
  group Drivers
    ../drivers/c/: gpio_port.c i2c.c pc_buffer.c spi.c timers.c uart.c
    ../drivers/include/: driver_defines.h
  group New Group
    ../peripherals/c/: accel.c ece353_images.c eeprom.c ft6x06.c launchpad_io.c lcd.c lcd_images.c serial_debug.c spi_select.c ws2812b_ice.c
    ./: IO_Expander.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
