# Keil uVision project nRF24L01p_Demo.uvprojx, settings and files
target nRF24L01p_Demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 uC99=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c interrupts.c
  group drivers
    ../drivers/c/: gpio_port.c pc_buffer.c spi.c uart.c
  group Lib
    ./: ece353_nrf24l01p.lib
  group peripherals
    ../peripherals/c/: serial_debug.c spi_select.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
